Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: BOSCO.IFC
Time: 2023-09-26T18:02:01
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: BOSCO_in de grond
In: Default Storey
Material: Steel
